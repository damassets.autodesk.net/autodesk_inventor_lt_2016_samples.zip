# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 3.0 (M020) (file servo.prt.1)

Parameters:
  METRIC = "NO"

Other parameters: DRILL_POINT_ANGLE, DRILL_DEPTH, DRILL_DIAMETER